* This is a comment.

*R1 0 1 30
*R2 1 2 10
*VDD 2 0 DC 3
*I 2 0 DC 5

R1 2 6 1
R2 2 3 1
R3 2 1 1
R4 6 7 1
R5 6 5 1
R6 5 1 1
R7 7 3 1
R8 1 0 1
R9 3 0 1
R10 5 4 1
R11 7 4 1
R12 4 0 1
*I1 0 2 DC 1
V1 6 0 DC 1
