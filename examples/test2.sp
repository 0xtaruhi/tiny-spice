* linear
* example 1

R1 1 2 10
R2 0 4 10
R3 2 4 10
R4 0 3 10
R5 3 4 10
R6 2 3 10
VDD 1 0 DC 30
